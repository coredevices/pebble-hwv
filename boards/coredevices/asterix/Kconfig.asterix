## boards/coredevices/asterix/asterix_defconfig
```kconfig
CONFIG_ARM_MPU=y
CONFIG_HW_STACK_PROTECTION=y

CONFIG_CLOCK_CONTROL_NRF_K32SRC_20PPM=y
```
